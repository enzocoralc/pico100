File: pico100.kicad_pcb (KiCad board)
At the start: 2 copper layers, 94.6 x 61.5 mm, 42 parts

Commit message: cleaned some traces in the pcb
Routing:
- net P16: track 45.4 -> 43.6 mm
